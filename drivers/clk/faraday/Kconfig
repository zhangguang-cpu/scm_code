## drivers/clk/faraday/Kconfig
```kconfig
config SCU_LEO
        tristate "SCM701D SCU conctrol driver"
        ---help---
          This driver supports SCM701D SCU conctrol
```
